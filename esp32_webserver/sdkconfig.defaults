## esp32_webserver/sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_WIFI_SSID="CodyOsMegaSoedIStuen"
CONFIG_EXAMPLE_WIFI_PASSWORD="MandeCodyEmil"
```
